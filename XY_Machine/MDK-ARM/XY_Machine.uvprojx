# Keil uVision project XY_Machine.uvprojx, settings and files
target XY_Machine (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32G431CBUx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.2.1
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: XY_Machine +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G431xx
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;../BSP/Inc;../BSP/Src;../App/Inc;../App/Src;../Components/TMC2209;..\Middlewares\grbl;..\Components\AT24C64
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32g431xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c i2c.c spi.c tim.c usart.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_i2c.c stm32g4xx_hal_i2c_ex.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group BSP
    ../BSP/Src/: board_motor.c board_serial.c board_step_test.c MyDelay.c
    ../BSP/Inc/: board_motor.h board_serial.h board_step_test.h MyDelay.h
  group App
    ../App/Src/: app.c
    ../App/Inc/: app.h
  group Components
    ../Components/TMC2209/: tmc2209.c tmc2209.h
    ../Components/AT24C64/: AT24C64.c AT24C64.h
  group Middlewares
    ../Middlewares/grbl/: config.h coolant_control.c coolant_control.h cpu_map.h defaults.h eeprom.c eeprom.h gcode.c gcode.h grbl.h grbl_limits.c grbl_limits.h grbl_serial.c grbl_serial.h grbl_start.c jog.c jog.h main.c motion_control.c motion_control.h nuts_bolts.c nuts_bolts.h planner.c planner.h print.c print.h probe.c probe.h protocol.c protocol.h report.c report.h settings.c settings.h spindle_control.c spindle_control.h stepper.c stepper.h system.c system.h
software components: CMSIS:CORE 4.3.0
